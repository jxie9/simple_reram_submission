v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {4x4crossbar.sym} 0 -10 0 1 {name=x1}
C {iopin.sym} -150 50 0 1 {name=p12 lab=SL1_raw}
C {devices/lab_pin.sym} -150 -130 0 0 {name=l14 sig_type=std_logic lab=vssa_raw}
C {iopin.sym} -150 70 0 1 {name=p2 lab=SL2_raw}
C {iopin.sym} -150 90 0 1 {name=p3 lab=SL3_raw}
C {iopin.sym} -150 110 0 1 {name=p4 lab=SL4_raw}
C {iopin.sym} -150 -30 0 1 {name=p5 lab=WL1_raw}
C {iopin.sym} -150 -10 0 1 {name=p7 lab=WL2_raw}
C {iopin.sym} -150 10 0 1 {name=p8 lab=WL3_raw}
C {iopin.sym} -150 30 0 1 {name=p9 lab=WL4_raw}
C {iopin.sym} -150 -110 0 1 {name=p6 lab=BL1_raw}
C {iopin.sym} -150 -90 0 1 {name=p10 lab=BL2_raw}
C {iopin.sym} -150 -70 0 1 {name=p11 lab=BL3_raw}
C {iopin.sym} -150 -50 0 1 {name=p13 lab=BL4_raw}
C {devices/iopin.sym} -150 -200 2 0 {name=p44 lab=vssa_raw}
